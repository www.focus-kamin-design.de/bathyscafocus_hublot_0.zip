Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Numéro du projet
Time: 2019-05-16T16:43:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160217_0900(x64) - Exporter 17.0.411.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu May 16 16:43:54 2019 * Host: FRED * Database: C:\Users\fr3d\AppData\Local\Temp\{053823BA-062E-46F6-B69E-6AFA98F9C030}\ifc * Database version: 5507 * Database creation date: Thu May 16 16:43:52 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu May 16 16:43:52 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu May 16 16:43:52 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm
Autre - Adresse du projet: ## Rue Ville, Code postal; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: ## Rue Ville, Code postal; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: M_Marqueur de niveau - Cercle: M_Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification - Nom du type: Pointe 8 mm; Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm; Nom de la famille: Niveau
Contraintes - Elévation: 0 mm; Base de l'élévation: Point de base du projet
Cotes - Hauteur de calcul: 0 mm

# IfcBuildingElementProxy, 28491b3e-56c6-4faf-acf5-00031d880248:28491b3e-56c6-4faf-acf5-00031d880248:201812
In: Niveau 1
Type - Material: Plate, Clear - Light
Type - Autre - Catégorie: Equipement spécialisé
Type - Données d'identification - Coût: 0; Description: Fireplace; Fabricant: FOCUS; Modèle: BATHISCAFOCUS; Numéro OmniClass: 23.40.20.34; Titre OmniClass: Fireplaces and Stoves; URL: https://www.focus-creation.com/bathyscafocus-hublot
Pset_ManufacturerTypeInformation - Manufacturer: FOCUS
Autre - Famille: 28491b3e-56c6-4faf-acf5-00031d880248: 28491b3e-56c6-4faf-acf5-00031d880248; Famille et type: 28491b3e-56c6-4faf-acf5-00031d880248: 28491b3e-56c6-4faf-acf5-00031d880248; ID du type: 28491b3e-56c6-4faf-acf5-00031d880248: 28491b3e-56c6-4faf-acf5-00031d880248; Type: 28491b3e-56c6-4faf-acf5-00031d880248: 28491b3e-56c6-4faf-acf5-00031d880248
Contraintes - Décalage: 0 mm; Hôte: Aucun(e)
Cotes - Surface: 3.46547 m2; Volume: 1.04001 m3
Phase de construction - Phase de création: Nouvelle construction
